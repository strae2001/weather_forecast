# Keil uVision project Project.uvprojx, settings and files
target Template (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: .\Drivers\CMSIS\Device\ST\STM32F1xx\Include;.\Drivers\STM32F1xx_HAL_Driver\Inc;.\Drivers\CMSIS\Include;.\Drivers;.\Users;.\Drivers\SYSTEM\delay;.\Drivers\SYSTEM\sys;.\Drivers\SYSTEM\usart;.\Drivers\BSP;.\Drivers\BSP\cJSON
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ./Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xb.s
  group Drivers/STM32F1xx_HAL_Driver
    ./Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_uart.c
  group Drivers/SYSTEM
    ./Drivers/SYSTEM/delay/: delay.c
    ./Drivers/SYSTEM/sys/: sys.c
    ./Drivers/SYSTEM/usart/: uart1.c
  group Drivers/BSP
    ./Drivers/BSP/: key.c led.c OLED.c esp8266.c weather.c
    ./Drivers/BSP/cJSON/: cJSON.c
  group User
    ./Users/: main.c stm32f1xx_it.c
    ./Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
